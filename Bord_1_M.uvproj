# Keil uVision project Bord_1_M.uvproj, settings and files
target Target 1 (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: LPC1768 NXP
  cpu: IRAM(0x10000000-0x10007FFF) IRAM2(0x2007C000-0x20083FFF) IROM(0-0x7FFFF) CLOCK(12000000) CPUTYPE("Cortex-M3")
  output: Bord_1_M +hex
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c include: .\Drivers
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x10000000 size 0x8000
  memory RVCT10: RAM 0x2007c000 size 0x8000
  group Src
    ./: startup_LPC17xx.s system_LPC17xx.c Bord_1_M.c
  group RTX
    ./RTX/: RTX_Conf_CM.c
  group Lib
    ./Drivers/: uart.c gpio.c sys_uart.c delay.c
    ./: OS_Ex.c
